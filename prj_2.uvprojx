# Keil uVision project prj_2.uvprojx, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: prj_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\hardware
  group User
    ./user/: main.c
  group Hardware
    ./hardware/: OLED_STC15.c OLED_Data.c delay.c matrix_key.c motor.c
